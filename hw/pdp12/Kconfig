## hw/pdp12/Kconfig
```kconfig
config PDP12_VIRT
    bool
    default y
    depends on PDP12
    select SERIAL
    select SERIAL_MM
    select VIRTIO_MMIO
    select DEVICE_TREE
```
